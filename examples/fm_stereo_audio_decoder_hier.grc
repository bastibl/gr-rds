options:
  parameters:
    author: Johannes Demel
    category: '[FM Radio]'
    generate_options: hb
    id: fm_stereo_audio_decoder
    output_language: python
    title: FM Stereo Audio Decoder
  states: {}

blocks:
- name: audio_adjustment_factor
  id: variable
  parameters:
    value: '1.012'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: int(baseband_rate / audio_rate)
  states: {}
- name: audio_decim_rate
  id: variable
  parameters:
    value: int(baseband_rate/audio_decim)
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_decim_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_decim_rate
    tau: '75e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2 * math.pi * (19000+200) / baseband_rate
    min_freq: 2 * math.pi * (19000-200) / baseband_rate
    w: '0.001'
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    label: Audio Device Rate
    type: eng_float
    value: 48e3
  states: {}
- name: baseband_rate
  id: parameter
  parameters:
    label: FM Baseband rate
    type: eng_float
    value: 250e3
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(1.*(volume+15)/10)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(1.*(volume+15)/10)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: audio_decim
    taps: firdes.low_pass(1.0,baseband_rate,13e3,3e3)
    type: fff
  states: {}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.complex_band_pass(1.0,baseband_rate,19e3-500,19e3+500,1e3)
    type: fcc
  states: {}
- name: fir_filter_xxx_3
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.band_pass(1.0,baseband_rate,38e3-13e3,38e3+13e3,3e3)
    type: fff
  states: {}
- name: fir_filter_xxx_5
  id: fir_filter_xxx
  parameters:
    decim: audio_decim
    taps: firdes.low_pass(1.0,baseband_rate,20e3,40e3)
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: L
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: R
    type: float
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: DSBSC Debug
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_1_0
  id: pad_sink
  parameters:
    label: Pilot Debug
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_1_0_0
  id: pad_sink
  parameters:
    label: L+R Debug
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_1_0_0_0
  id: pad_sink
  parameters:
    label: L-R Debug
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: int(audio_rate * audio_adjustment_factor)/float(audio_decim_rate)
    type: fff
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: int(audio_rate * audio_adjustment_factor)/float(audio_decim_rate)
    type: fff
  states: {}
- name: volume
  id: parameter
  parameters:
    label: Volume
    type: eng_float
    value: '-15.'
  states: {}

connections:
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_1, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_imag_0, '0', pad_sink_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_5, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_imag_0, '0']
- [blocks_sub_xx_0, '0', analog_fm_deemph_0_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_1, '0', blocks_sub_xx_0, '1']
- [fir_filter_xxx_1, '0', pad_sink_0_1_0_0, '0']
- [fir_filter_xxx_2, '0', analog_pll_refout_cc_0, '0']
- [fir_filter_xxx_3, '0', blocks_multiply_xx_0, '0']
- [fir_filter_xxx_3, '0', pad_sink_0_1, '0']
- [fir_filter_xxx_5, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_5, '0', blocks_sub_xx_0, '0']
- [fir_filter_xxx_5, '0', pad_sink_0_1_0_0_0, '0']
- [pad_source_0, '0', fir_filter_xxx_1, '0']
- [pad_source_0, '0', fir_filter_xxx_2, '0']
- [pad_source_0, '0', fir_filter_xxx_3, '0']
- [pfb_arb_resampler_xxx_0, '0', pad_sink_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', pad_sink_0_0, '0']

metadata:
  file_format: 1
