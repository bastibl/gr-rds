options:
  parameters:
    category: RDS
    generate_options: qt_gui
    id: rds_tx
    output_language: python
  states: {}

blocks:
- name: fm_max_dev
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 87.5e6
  states: {}
- name: input_gain
  id: variable
  parameters:
    comment: |-
      FM Stereo &-RDS TX  Mod. index % : 
      42,5% (L+R) 
      42,5% (L-R) DSB SC
      10% 19khz tone
      5%   RDS BPSK DSB SC
    value: '0.425'
  states: {}
- name: pilot_gain
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: rds_gain
  id: variable
  parameters:
    value: 2000 / fm_max_dev
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 19e3*20
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    comment: |-
      Time constant in seconds 
      (75us in US, 50us in EUR)
    fh: '-1.0'
    samp_rate: 48e3
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0_0
  id: analog_fm_preemph
  parameters:
    comment: |-
      Time constant in seconds 
      (75us in US, 50us in EUR)
    fh: '-1.0'
    samp_rate: 48e3
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pilot_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: rds_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: gr_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: gr_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: gr_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: gr_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*fm_max_dev/usrp_rate
  states: {}
- name: gr_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,2]'
  states: {}
- name: gr_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: gr_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: gr_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: gr_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: input_gain
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: input_gain
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    if_gain0: '30'
    sample_rate: 1e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '380000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    showports: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '38'
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 89.8e6
    max_latency: '104'
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: WDR 3
    pty: '14'
    pty_locale: '0'
    radiotext: GNU Radio <3
    ta: 'False'
    tp: 'True'
  states: {}
- name: rds_tag_to_msg_0
  id: rds_tag_to_msg
  parameters:
    num_inputs: '1'
    type: complex
    vlen: '1'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '160'
    gain: '111'
    interp: '160'
    ntaps: 160*11
    samp_rate: usrp_rate
    sym_rate: '2375'
    type: interp_fir_filter_fff
  states: {}
- name: uhd_usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: '40'
    len_tag_name: ''
    samp_rate: 1e6
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_fm_preemph_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_complex_to_imag_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_1, '0']
- [audio_source_0, '0', analog_fm_preemph_0, '0']
- [audio_source_0, '1', analog_fm_preemph_0_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_imag_0_0, '0', gr_multiply_xx_1, '0']
- [blocks_complex_to_imag_0_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', gr_add_xx_1, '1']
- [blocks_multiply_const_vxx_1, '0', gr_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_complex_to_imag_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', blocks_complex_to_imag_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [gr_add_xx_0, '0', low_pass_filter_0_0, '0']
- [gr_add_xx_1, '0', gr_frequency_modulator_fc_0, '0']
- [gr_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [gr_diff_encoder_bb_0, '0', gr_map_bb_1, '0']
- [gr_frequency_modulator_fc_0, '0', rational_resampler_xxx_1, '0']
- [gr_frequency_modulator_fc_0, '0', rds_tag_to_msg_0, '0']
- [gr_map_bb_1, '0', gr_unpack_k_bits_bb_0, '0']
- [gr_multiply_xx_0, '0', gr_add_xx_1, '0']
- [gr_multiply_xx_1, '0', gr_add_xx_1, '2']
- [gr_sub_xx_0, '0', low_pass_filter_0_0_0, '0']
- [gr_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [low_pass_filter_0_0, '0', gr_add_xx_1, '3']
- [low_pass_filter_0_0_0, '0', gr_multiply_xx_1, '1']
- [network_socket_pdu_0, pdus, rds_encoder_0, rds in]
- [rational_resampler_xxx_0, '0', gr_add_xx_0, '0']
- [rational_resampler_xxx_0, '0', gr_sub_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', gr_add_xx_0, '1']
- [rational_resampler_xxx_0_0, '0', gr_sub_xx_0, '1']
- [rational_resampler_xxx_1, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_1, '0', uhd_usrp_sink, '0']
- [rds_encoder_0, '0', gr_diff_encoder_bb_0, '0']
- [rds_tag_to_msg_0, strobe, rds_encoder_0, strobe]
- [root_raised_cosine_filter_0, '0', gr_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
